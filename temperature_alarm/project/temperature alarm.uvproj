# Keil uVision project temperature alarm.uvproj, settings and files
target temperature alarm (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: temperature alarm +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\inc;..\user
  group startup
    ./: STARTUP.A51
  group src
    ../src/: lcd.c temp.c
  group user
    ../user/: beep.c booth.c main.c
